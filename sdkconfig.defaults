## sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_DPP_SUPPORT=y
CONFIG_LV_USE_USER_DATA=y
CONFIG_LV_COLOR_DEPTH_1=y
```
